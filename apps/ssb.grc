options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ssb
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '429000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_rate * 40
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '2800'
    interp: '1'
    low_cutoff_freq: '100'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '2800'
    interp: '1'
    low_cutoff_freq: '100'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '-200'
    interp: '1'
    low_cutoff_freq: '-2800'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: band_pass_filter_0_0_1
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '2800'
    interp: '1'
    low_cutoff_freq: '100'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.747'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ssbaudioprocessed.wav
    repeat: 'True'
  states: {}
- name: cessb_clipper_cc_0
  id: cessb_clipper_cc
  parameters:
    clip: '0.353553390593'
  states: {}
- name: cessb_stretcher_cc_0
  id: cessb_stretcher_cc
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '32768'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(429050000, 100000)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=65536,num_send_frames=128,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: '40'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: clipper-filter
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: clipper-filter
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [band_pass_filter_0, '0', cessb_clipper_cc_0, '0']
- [band_pass_filter_0_0, '0', cessb_stretcher_cc_0, '0']
- [band_pass_filter_0_0_0, '0', cessb_clipper_cc_0, '0']
- [band_pass_filter_0_0_1, '0', rational_resampler_xxx_2, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [cessb_clipper_cc_0, '0', virtual_sink_0, '0']
- [cessb_stretcher_cc_0, '0', band_pass_filter_0_0_1, '0']
- [rational_resampler_xxx_2, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', band_pass_filter_0_0, '0']

metadata:
  file_format: 1
