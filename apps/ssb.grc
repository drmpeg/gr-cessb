options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ssb
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: band_pass_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: high_cutoff - ((high_cutoff + low_cutoff)  * sideband)
    low_cutoff_freq: low_cutoff - ((high_cutoff + low_cutoff) * sideband)
    samp_rate: audio_rate
    type: complex_band_pass
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '429000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '89'
    value: '45'
  states: {}
- name: high_cutoff
  id: variable
  parameters:
    value: '2800'
  states: {}
- name: low_cutoff
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_rate * 40
  states: {}
- name: sideband
  id: variable_qtgui_chooser
  parameters:
    label: sideband select
    label0: USB
    label1: LSB
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ssbaudioprocessed.wav
    repeat: 'True'
  states: {}
- name: cessb_clipper_cc_0
  id: cessb_clipper_cc
  parameters:
    clip: '0.353553390593'
  states: {}
- name: cessb_stretcher_cc_0
  id: cessb_stretcher_cc
  parameters: {}
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024 * 32
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(429050000, 100000)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=65536,num_send_frames=128,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: clipper-filter
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: clipper-filter
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', fft_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [cessb_clipper_cc_0, '0', virtual_sink_0, '0']
- [cessb_stretcher_cc_0, '0', fft_filter_xxx_0_0_0, '0']
- [fft_filter_xxx_0, '0', cessb_clipper_cc_0, '0']
- [fft_filter_xxx_0_0, '0', cessb_stretcher_cc_0, '0']
- [fft_filter_xxx_0_0_0, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_2, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_2, '0', uhd_usrp_sink_0, '0']
- [virtual_source_0, '0', fft_filter_xxx_0_0, '0']

metadata:
  file_format: 1
